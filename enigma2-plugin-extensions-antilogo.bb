MODULE = "AntiLogo"
DESCRIPTION = "Prevent logo retention"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
