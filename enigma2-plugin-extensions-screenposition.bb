MODULE = "ScreenPosition"
DESCRIPTION = "Adjust the screen position"
PACKAGE_ARCH = "${MACHINE_ARCH}"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
