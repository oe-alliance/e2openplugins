MODULE = "SystemTools"
DESCRIPTION = "System Tools for enigma2 stb"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
