MODULE = "CacheFlush"
DESCRIPTION = "periodicaly flushing cache"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
