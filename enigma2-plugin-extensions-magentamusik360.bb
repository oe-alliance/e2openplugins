MODULE = "MagentaMusik360"

DESCRIPTION = "MagentaMusik 360 Plugin"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
