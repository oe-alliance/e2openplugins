MODULE = "Buienradar"
DESCRIPTION = "Buienradar actuele situatie"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
