MODULE = "SetPicon"
DESCRIPTION = "Work with services picons"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
