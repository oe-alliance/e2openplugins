MODULE = "PermanentVfdClock"
DESCRIPTION = "Show clock in VFD permanently"

PR="r0"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
