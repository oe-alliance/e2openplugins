MODULE = "AnalogClock"

DESCRIPTION = "permanent analog clock on the screen"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
