MODULE = "MeteoViewer"
DESCRIPTION = "meteo pictures viewer"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
