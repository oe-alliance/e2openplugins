MODULE = "TelekomSport"

DESCRIPTION = "Telekom Sport Plugin"

require openplugins-replace-pli.inc

require openplugins-setuptools3.inc

require assume-gplv2.inc
